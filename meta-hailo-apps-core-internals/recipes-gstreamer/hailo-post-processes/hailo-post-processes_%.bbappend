require conf/include/hailo-apps-core-src-internal.inc
S = "${HAILO_APPS_CORE_DIR}/core/hailo"
