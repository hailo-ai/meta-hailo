require include/core-image-append.inc
